# Keil uVision project phone.uvproj, settings and files
target Cortex-M3 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: phone +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Source\Libraries\CMSIS\CM3\CoreSupport;..\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\APP;..\Source\BSP;..\Source\BSP\LED;..\Source\BSP\LCD1602;..\Source\BSP\ADC;..\Source\BSP\SysTick
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
    ../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group FWlib
    ../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_dma.c stm32f10x_adc.c
  group APP
    ../Source/APP/: App.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group BSP
    ../Source/BSP/: BSP.c
    ../Source/BSP/LCD1602/: LCD_1602.c
    ../Source/BSP/ADC/: bsp_adc.c
    ../Source/BSP/LED/: bsp_led.c
    ../Source/BSP/SysTick/: delay.c
  group DOC
    ../Doc/: readme.txt
