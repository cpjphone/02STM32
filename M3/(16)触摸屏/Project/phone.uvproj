# Keil uVision project phone.uvproj, settings and files
target Cortex-M3 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: phone +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Source\Libraries\CMSIS\CM3\CoreSupport;..\Source\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Source\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\APP;..\Source\BSP;..\Source\BSP\usart;..\Source\BSP\lcd;..\Source\BSP\spi_flash;..\Source\BSP\SysTick;..\Source\BSP\touch;..\Source\BSP\LED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../Source/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../Source/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h stm32f10x.h
  group FWlib
    ../Source/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_spi.c
  group APP
    ../Source/APP/: App.c stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group BSP
    ../Source/BSP/: BSP.c
    ../Source/BSP/SysTick/: delay.c
    ../Source/BSP/usart/: bsp_usart1.c
    ../Source/BSP/spi_flash/: bsp_spi_flash.c
    ../Source/BSP/lcd/: bsp_ili9341_lcd.c
    ../Source/BSP/touch/: bsp_gpio_spi.c bsp_touch.c
    ../Source/BSP/LED/: bsp_led.c
  group DOC
    ../Doc/: readme.txt
