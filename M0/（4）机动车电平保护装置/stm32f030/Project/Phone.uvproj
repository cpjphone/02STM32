# Keil uVision project Phone.uvproj, settings and files
target Cortex-M0 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Phone +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\Source\Libraries\CMSIS;..\Source\Libraries\inc;..\Source\Libraries\startup;..\Source\APP;..\Source\BSP\delay;..\Source\BSP\LED;..\Source\BSP\Usart;..\Source\BSP\NRF24L01;..\Source\BSP\GSM900;..\Source\BSP\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Startup
    ../Source/Libraries/startup/: startup_stm32f0xx_ld.s
    ../Source/Libraries/CMSIS/: stm32f0xx_conf.h system_stm32f0xx.c
  group FWLib
    ../Source/Libraries/src/: stm32f0xx_gpio.c stm32f0xx_flash.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_wwdg.c stm32f0xx_misc.c stm32f0xx_tim.c
  group APP
    ../Source/APP/: App.c stm32f0xx_it.c
  group BSP
    ../Source/BSP/: BSP.c
    ../Source/BSP/delay/: delay.c
    ../Source/BSP/LED/: led.c
    ../Source/BSP/Usart/: Usart.c
    ../Source/BSP/NRF24L01/: bsp_spi_nrf.c
    ../Source/BSP/GSM900/: GSM.c
    ../Source/BSP/TIMER/: time.c
